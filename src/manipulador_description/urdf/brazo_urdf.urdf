Commit message: configuracion_pid

File: src/manipulador_description/urdf/brazo_urdf.urdf (robot description, URDF)
Before this commit: robot brazo_urdf, 6 links, 5 joints
Joints:
- joint joint_4: limit lower=0 upper=-3.142 effort=200 velocity=3 -> lower=-3.142 upper=3.142 effort=200 velocity=3
